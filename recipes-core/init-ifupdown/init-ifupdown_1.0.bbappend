INITSCRIPT_PARAMS = "start 01 . stop 80 0 6 1 ."
